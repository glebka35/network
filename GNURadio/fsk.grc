options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '45.4545'
  states: {}
- name: center
  id: variable
  parameters:
    value: '2210'
  states: {}
- name: delta_f_over_f0
  id: variable_qtgui_range
  parameters:
    comment: Small delta_f
    gui_hint: 0,2,1,1
    orient: Qt.Horizontal
    start: '-1.0e-4'
    step: '1.0e-6'
    stop: '1.0e-4'
    value: '0'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '170'
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: '0.068'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '0.2'
    value: '0'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '1056'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-130'
    step: '5'
    stop: '0'
    value: '-100'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: '0.850'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation/8.0)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.850'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '-48'
    type: float
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/gleb/Documents/mipt/network/GNURadio/gleb
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.068'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: samp_rate
    sensitivity: '15708'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: delta_f_over_f0
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,1000,400)
    type: fcc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: '48000'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-200'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '16384'
    srate: samp_rate
    type: float
    update_time: '0.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    type: float
    ymin: '0.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '"xmt_data"'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '"fsk_out"'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '"xmt_data"'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '"fsk_out"'
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', digital_binary_slicer_fb_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_repeat_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_vco_f_0, '0', virtual_sink_1, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', channels_channel_model_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
